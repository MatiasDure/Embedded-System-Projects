# Keil uVision project lesson.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: stm32c0xx_it.c stm32c0xx_hal_msp.c system_stm32c0xx.c main.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32c031xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c
  group App
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: bsp.c ring_buffer.h delay.c delay.h
  group Drivers
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: lcd1602.c lcd1602.h led.c led.h
software components: CMSIS:CORE 6.1.1, Device:CubeMX 1.0.0
